Properties of the parts of a building model (IFC4), part 3 of 3

# IfcBuildingElementProxy: 5 миди.stp[957]
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[958]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[959]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[95]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[960]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[961]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[962]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[963]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[964]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[965]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[966]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[967]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[968]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[969]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[96]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[970]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[971]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[972]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[973]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[974]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[975]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[976]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[977]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[978]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[979]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[97]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[980]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[981]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[982]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[983]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[984]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[985]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[986]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[987]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[988]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[989]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[98]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[990]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[991]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[992]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[993]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[994]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[995]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[996]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[997]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[998]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[999]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[99]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 миди.stp[9]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль (66)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль — обрезан 1600 (22)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
